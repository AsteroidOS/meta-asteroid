SUMMARY = "HAL libhybris backend for GeoClue"
HOMEPAGE = "https://github.com/mer-hybris/geoclue-providers-hybris"

QMAKE_PROFILES = "${S}/hal/hallocationbackend.pro"

require geoclue-provider-hybris.inc
