FILESEXTRAPATHS_prepend := "${THISDIR}/pulseaudio:"
SRC_URI += " file://1002-build-Install-pulsecore-headers.patch "
