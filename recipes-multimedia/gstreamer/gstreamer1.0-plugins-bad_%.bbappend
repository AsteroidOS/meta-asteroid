FILESEXTRAPATHS_prepend := "${THISDIR}/gstreamer1.0-plugins-bad:"
SRC_URI += " file://0001-photography-add-missing-vmethods.patch \
             file://0002-camerabin-install-GST_PHOTOGRAPHY_PROP_EXPOSURE_MODE.patch"
