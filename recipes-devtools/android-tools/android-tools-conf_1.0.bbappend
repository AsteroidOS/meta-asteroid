S = "${WORKDIR}/sources"
UNPACKDIR = "${S}"
