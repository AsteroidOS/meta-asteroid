PACKAGECONFIG:append = " curl"
