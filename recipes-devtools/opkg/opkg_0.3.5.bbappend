PACKAGECONFIG_append = " curl"
