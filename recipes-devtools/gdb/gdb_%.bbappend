PACKAGECONFIG:append = " xz python readline "
