FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0003-Add-necessary-include-file.patch;patchdir=../../.."

