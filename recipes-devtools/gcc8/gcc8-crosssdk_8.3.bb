require gcc8-cross_${PV}.bb
require gcc8-crosssdk.inc
