require gcc8-${PV}.inc
require gcc8-source.inc

EXCLUDE_FROM_WORLD = "1"
