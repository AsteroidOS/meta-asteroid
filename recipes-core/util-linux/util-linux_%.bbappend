FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Make-lsfd-call-to-bsearch-compatible-with-glibc-2.38.patch"

