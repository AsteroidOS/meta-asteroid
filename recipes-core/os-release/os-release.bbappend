OS_RELEASE_FIELDS += "\
    BUILD_ID LOGO HOME_URL \
"
OS_RELEASE_UNQUOTED_FIELDS += " LOGO"
HOME_URL = "https://asteroidos.org/"
LOGO = "logo-asteroidos"
