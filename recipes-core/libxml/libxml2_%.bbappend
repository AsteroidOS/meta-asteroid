EXTRA_OECONF:append = " --with-http"
