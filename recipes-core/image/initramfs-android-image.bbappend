BAD_RECOMMENDATIONS += "busybox-syslog ldconfig"

IMAGE_INSTALL:remove = "android-tools"
