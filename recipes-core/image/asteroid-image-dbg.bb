inherit asteroid-image
DESCRIPTION = "Asteroid image for debuggers, contains debugging tools"
EXTRA_IMAGE_FEATURES += "dbg-pkgs tools-debug tools-testapps allow-empty-password allow-root-login empty-root-password post-install-logging"
