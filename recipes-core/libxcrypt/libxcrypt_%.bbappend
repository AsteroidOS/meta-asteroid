# update to version 4.5.2 to compile with gcc15
SRCREV = "db70b42bd7b2a5b00a8580c8dec0aa66791c950a"
LIC_FILES_CHKSUM = "file://LICENSING;md5=b65434749329c34b5d32c2df3f1b4112 \
                    file://COPYING.LIB;md5=4fbd65380cdd255951079008b364516c \
                    "
