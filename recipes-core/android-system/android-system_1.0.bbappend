RDEPENDS:${PN}:remove = "lxc libgbinder-tools mtk-connectivity"
