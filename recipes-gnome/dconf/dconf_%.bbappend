EXTRA_OECONF += "--disable-editor"
DEPENDS_remove = "gtk+3"
DEPENDS_remove = "libxml2"
DEPENDS += "dbus"
REQUIRED_DISTRO_FEATURES_remove = "x11"
