SUMMARY = "Asteroid's flashlight app"
HOMEPAGE = "https://github.com/AsteroidOS/asteroid-flashlight.git"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://LICENSE;md5=84dcc94da3adb52b53ae4fa38fe49e5d"

SRC_URI = "git://github.com/AsteroidOS/asteroid-flashlight.git;protocol=https;branch=master"
SRCREV = "74a3638f4f4572dcee9270e32892a61ed196bc7a"
PV = "2.1+28+git"

require asteroid-app.inc
