SUMMARY = "Asteroid's flashlight app"
HOMEPAGE = "https://github.com/AsteroidOS/asteroid-flashlight.git"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://LICENSE;md5=84dcc94da3adb52b53ae4fa38fe49e5d"

SRC_URI = "git://github.com/AsteroidOS/asteroid-flashlight.git;protocol=https;branch=2.0"
SRCREV = "cd106ae07b9afadca712ae34a3ba8edd1a8f5148"

require asteroid-app.inc
