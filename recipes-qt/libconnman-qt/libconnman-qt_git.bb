inherit qmake5

require libconnman-qt.inc
