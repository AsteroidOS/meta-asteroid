FILESEXTRAPATHS_prepend := "${THISDIR}/qtmqtt:"
SRC_URI += " file://0001-Disable-building-of-examples-relying-on-QtWidgets.patch "
