RDEPENDS_${PN}-tools-dev += "python"
