FILESEXTRAPATHS:prepend := "${THISDIR}/qttools:"
SRC_URI += " file://0001-Build-kmap2qmap-tool.patch \
        file://0002-kmap2qmap-Map-MenuKB-key.patch"
