EXTRA_QMAKEVARS_PRE += "QMAKE_CFLAGS_ISYSTEM="
