RDEPENDS:${PN}-tools-dev += "python"
