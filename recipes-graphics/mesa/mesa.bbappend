FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-meson-use-system-C11-threads-when-available.patch"
