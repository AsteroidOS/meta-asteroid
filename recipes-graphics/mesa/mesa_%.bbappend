PACKAGECONFIG_append_qemux86 = " gallium"
GALLIUMDRIVERS_append_x86 = ",virgl"
