# Remove dependencies to meta/mesa
PACKAGECONFIG_remove = "kms"
PACKAGECONFIG_remove = "wayland"
