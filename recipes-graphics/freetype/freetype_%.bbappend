PACKAGECONFIG:append = " pixmap"
