FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-use-system-c11-threads-for-glibc-2.43.patch"
